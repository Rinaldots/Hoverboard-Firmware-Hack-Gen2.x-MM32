# Keil uVision project Hoverboard.uvprojx, settings and files
target MM32SPIN05 (6240000::V6.24::ARMCLANG)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HoverboardOutputMM32SPIN05 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\Library\MM32SPIN05\HAL_Lib\Inc;.\RTE\_MM32SPIN05
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Src
    ./Src/: main.c delay.c bldc.c initialize.c interrupt.c uart.c remoteUartBus.c calculation.c hardware.c sim_eeprom.c ipark.c pwm_gen.c FOC_Math.c clarke.c hallhandle.c park.c PID.c
  group Inc
    ./Inc/: bldc.h calculation.h delay.h initialize.h interrupt.h pinout.h remoteUartBus.h uart.h hardware.h sim_eeprom.h ipark.h pwm_gen.h FOC_Math.h clarke.h hallhandle.h park.h PID.h
  group HAL-SPIN05
    ./Library/MM32SPIN05/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group HAL-SPIN25
    ./Library/MM32SPIN25/HAL_lib/src/: hal_adc.c hal_comp.c hal_crc.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_op.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_wwdg.c
    ./Library/MM32SPIN25/HAL_lib/inc/: spin25-redefine.h
target MM32SPIN06 (6190000::V6.19::ARMCLANG)
  device: MM32SPIN06PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HoverboardOutputMM32SPIN06 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\Library\MM32SPIN05\HAL_Lib\Inc;.\RTE\_MM32SPIN05
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target MM32SPIN25 (6190000::V6.19::ARMCLANG)
  device: MM32SPIN25PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HoverboardOutputMM32SPIN25 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: TARGET_MM32SPIN25
  c include: .\Library\MM32SPIN25\HAL_lib\inc;.\RTE\_MM32SPIN05
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:Startup 1.0.4
